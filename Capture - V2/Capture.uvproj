# Keil uVision project Capture.uvproj, settings and files
target Capture (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Capture +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Includes;C:\Keil_v5\ARM\INC\NXP\LPC17xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s
    C:/Keil_v5/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
  group Application
    ./Application/: Capture.c
    ./: ADS1298_IO_Init.c
  group GPIO_Driver
    ./Drivers/GPIO/: gpio.c gpio.h
  group Terminal Driver
    ./Drivers/Terminal/: terminal.c
  group LED
    ./Drivers/LED/: status_led.c
  group Delay
    ./Drivers/Delay/: Delay.c
  group SPI_Driver
    ./Drivers/SSP/: ssp.c
